MACRO sky130_fd_pr__nfet_01v8_E5NSUL
  CLASS BLOCK ;
  FOREIGN sky130_fd_pr__nfet_01v8_E5NSUL ;
  ORIGIN 0.365 0.340 ;
  SIZE 0.730 BY 0.680 ;
  OBS
      LAYER li1 ;
        RECT -0.305 -0.230 -0.135 0.230 ;
        RECT 0.135 -0.230 0.305 0.230 ;
      LAYER mcon ;
        RECT -0.305 -0.150 -0.135 0.150 ;
        RECT 0.135 -0.150 0.305 0.150 ;
      LAYER met1 ;
        RECT -0.335 -0.210 -0.105 0.210 ;
        RECT 0.105 -0.210 0.335 0.210 ;
  END
END sky130_fd_pr__nfet_01v8_E5NSUL
END LIBRARY

